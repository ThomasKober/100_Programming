<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\L3_sBus_V1.2.ewp</path>
  </project>
  <batchBuild />
</workspace>
